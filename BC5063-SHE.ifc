Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2023-02-20T21:54:08
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20200210_1400(x64) - Exporter 20.2.12.1 - Alternate UI 20.2.12.1
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Mon Feb 20 21:54:08 2023 * Host: Yogoon * Database: C:\Users\gokul\AppData\Local\Temp\965cbf6d-762b-4767-b912-ee18d69de2f7\ba4bcc30-8f03-4ceb-aa8c-c112f13b8888\ifc * Database version: 5507 * Database creation date: Mon Feb 20 21:54:07 2023 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Mon Feb 20 21:54:07 2023 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Mon Feb 20 21:54:07 2023 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Pset_ProductRequirements - Category: Project Information
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuildingStorey: Level:8mm Head, Level 1
LongName: Level 1; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Identity Data(Type) - Type Name: 8mm Head
Graphics(Type) - Color: 0; Line Pattern: Centre; Line Weight: 1; Symbol: M_Level Head - Circle: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes
Constraints(Type) - Elevation Base: Project Base Point
Pset_AirSideSystemInformation - Name: Level 1
Pset_ProductRequirements - Name: Level 1; Category: Levels
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other - Category: Levels; Family: Level: 8mm Head; Family and Type: Level: 8mm Head; Type: Level: 8mm Head; Type Id: Level: 8mm Head

# IfcFlowController: BC5083-15, BC5083-15:BC5083-15:496115
In: Level 1
Type - PredefinedType: MIXING
Type - Constraints - Default Elevation: 0 mm
Type - Identity Data - AccessibilityPerformance: n/a; AssetIdentifier: n/a; AssetType: Fixed; BarCode: n/a; Category: Pr_40_20_87_78:Shower manual water supply sets; CodePerformance: WRAS_TMV3; Color: Chrome; Constituents: n/a; Description: ShowerValveExposed; DurationUnit: year; ExpectedLife: n/a; Features: n/a; Finish: Chrome; IfcExportAs: IfcValveType; IfcExportType: MIXING; InstallationDate: 31-12-1900 23:59; Manufacturer: info@dolphinsolutions.co.uk; ManufacturerName: DolphinsolutionsLimited; ManufacturerURL: http://www.dolphinsolutions.co.uk/; Material: Body_Elbows/ChromePlatedPolishedBrass_Lever/ChromePlatedZincDieCast; ModelNumber: BC5083-15; ModelReference: DolphinSolutionsLimited_ShowerManualWaterSupplySets_ShowerValveExpposed; Name: ShowerManualWaterSupplySets_ShowerValveExposed_BC5083-15_DolphinSolutionsLimited; NBSDescription: Showers; NBSReference: 45-35-70/333; NominalHeight: 109 mm; NominalLength: 122 mm; NominalWidth: 205 mm; ObjectClassification1: OmniClass; ObjectClassification2: 23.45.05.14.17; ReplacementCost: n/a; Size: 205x122x109; SustainabilityPerformance: n/a; TagNumber: n/a; Type Name: BC5083-15; Uniclass2015Code: Pr_40_20_87_78; Uniclass2015Title: Shower manual water supply sets; WarrantyDescription: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: year; WarrantyGuarantorLabor: DolphinSolutionsLimited; WarrantyGuarantorParts: DolphinSolutionsLimited; WarrantyStartDate: 31-12-1900 23:59
Type - Other - Category: Plumbing Fixtures; Family Name: BC5083-15
Type - Pset_ValveTypeFaucet - Finish: Chrome
Pset_DistributionFlowElementCommon - Reference: BC5083-15:BC5083-15; sets with these values: 2
Pset_ElementShading - Color: Chrome
Pset_ManufacturerOccurrence - BarCode: n/a
Pset_ManufacturerTypeInformation - ModelReference: DolphinSolutionsLimited_ShowerManualWaterSupplySets_ShowerValveExpposed; Manufacturer: info@dolphinsolutions.co.uk
Pset_ProductRequirements - Name: ShowerManualWaterSupplySets_ShowerValveExposed_BC5083-15_DolphinSolutionsLimited; Category: Plumbing Fixtures
Constraints - Level: Level: Level 1; Moves With Nearby Elements: no; Elevation from Level: 800 mm; Host: Level : Level 1; Offset from Host: 800 mm
Dimensions - Area: 0.0287295 m2; Volume: 0.000522682 m3
Identity Data - Mark: 428
Other - Family: BC5083-15: BC5083-15; Family and Type: BC5083-15: BC5083-15; Type: BC5083-15: BC5083-15; Type Id: BC5083-15: BC5083-15
Phasing - Phase Created: Phase 1

# IfcFlowTerminal: BC5023-07SS:Standard (2)
In: Level 1
Pset_DistributionFlowElementCommon - Reference: BC5023-07SS:Standard; sets with these values: 2
Pset_ElementShading - Color: Brushed Satin Polished-PSS
Pset_ManufacturerOccurrence - BarCode: n/a; SerialNumber: n/a
Pset_ManufacturerTypeInformation - ModelReference: DolphinSolutionsLimited_32mmGrabRail; Manufacturer: mailto:info@dolphinsolutions.co.uk
Pset_ProductRequirements - Name: SupportRails_800mmFoldDown32mmGrabRail_BC5023-07SS_DolphinSolutionsLimited; Category: Plumbing Fixtures
Constraints - Level: Level: Level 1; Moves With Nearby Elements: no; Elevation from Level: 567.285 mm; Host: Level : Level 1; Offset from Host: 567.285 mm
Dimensions - Area: 0.0683182 m2; Volume: 0.000693445 m3
Other - Category: Plumbing Fixtures; Family: BC5023-07SS: Standard; Family and Type: BC5023-07SS: Standard; Type: BC5023-07SS: Standard; Type Id: BC5023-07SS: Standard
Phasing - Phase Created: Phase 1
Other(Type) - Category: Plumbing Fixtures; Family Name: BC5023-07SS
Identity Data(Type) - AccessibilityPerformance: n/a; AssetIdentifier: n/a; AssetType: Fixed; BarCode: n/a; Category: Pr_40_20_76_84:SupportRails; CodePerformance: BSEN12182_DocM_BS8300; Color: Brushed Satin Polished-PSS; Constituents: n/a; Description: 800mm Contemporary Fold Down Grab Rail; DurationUnit: year; ExpectedLife: n/a; Features: 800mm Fold Down; Finish: Brushed Satin/ Polished-PSS; Form: Wall-mounted; Grade: 304; InstallationDate: 31-12-1900 23:59; Manufacturer: mailto:info@dolphinsolutions.co.uk; ManufacturerName: DolphinsolutionsLimited; ManufacturerURL: http://www.dolphinsolutions.co.uk/; Material: StainlessSteel; ModelNumber: BC5023-07SS/BC5023-07-PSS; ModelReference: DolphinSolutionsLimited_32mmGrabRail; Name: SupportRails_800mmFoldDown32mmGrabRail_BC5023-07SS_DolphinSolutionsLimited; NBSDescription: Support rails; NBSReference: 45-35-72/360; NBSTypeID: n/a; NominalHeight: 139 mm; NominalLength: 800 mm; NominalWidth: 100 mm; ObjectClassification_1: OmniClass; ObjectClassification_2: 23.40.20.27.14; ProductInformation: https://www.dolphinsolutions.co.uk/product/dolphin-contemporary-grab-rail/; ReplacementCost: n/a; Revision: n/a; SerialNumber: n/a; Shape: n/a; Size: 800 x 100 x 139 mm; SustainabilityPerformance: n/a; TagNumber: n/a; Type Name: Standard; Uniclass2015Code: Pr_40_20_76_84; Uniclass2015Title: Support rails; WarrantyDescription: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a; WarrantyStartDate: 31-12-1900 23:59
Dimensions(Type) - Depth: 800 mm; Height: 140 mm; Width: 100 mm
Constraints(Type) - Default Elevation: 0 mm
Name (BC5023-07SS:Standard:...) | Mark
495757 | 105
495763 | 111

# IfcFlowTerminal: BC5063-01:Standard, BC5063-01:Standard:495759
In: Level 1
Other(Type) - Category: Plumbing Fixtures; Family Name: BC5063-01
Pset_DistributionFlowElementCommon - Reference: BC5063-01:Standard; sets with these values: 2
Pset_ElementShading - Color: Brushed Satin
Pset_ManufacturerOccurrence - BarCode: n/a; SerialNumber: n/a
Pset_ManufacturerTypeInformation - ModelReference: DolphinSolutionsLimited_Roseless32mmGrabRail; Manufacturer: mailto:info@dolphinsolutions.co.uk
Pset_ProductRequirements - Name: SupportRails_Roseless32mmGrabRail_BC5063-01_DolphinSolutionsLimited; Category: Plumbing Fixtures
Constraints - Level: Level: Level 1; Moves With Nearby Elements: no; Elevation from Level: 665 mm; Host: Level : Level 1; Offset from Host: 665 mm
Dimensions - Area: 0.0520715 m2; Volume: 0.000103766 m3
Identity Data - Mark: 107
Other - Category: Plumbing Fixtures; Family: BC5063-01: Standard; Family and Type: BC5063-01: Standard; Type: BC5063-01: Standard; Type Id: BC5063-01: Standard
Phasing - Phase Created: Phase 1
Identity Data(Type) - AccessibilityPerformance: n/a; AssetIdentifier: n/a; AssetType: Fixed; BarCode: n/a; Category: Pr_40_20_76_84:SupportRails; CodePerformance: BSEN12182; Color: Brushed Satin; Constituents: n/a; Description: 450mm long roseless 32mm grab rail; DurationUnit: year; ExpectedLife: n/a; Features: Roseless 60mm wall clearance; Finish: Brushed Satin; Form: Wall-mounted; Grade: 304; InstallationDate: 31-12-1900 23:59; Manufacturer: mailto:info@dolphinsolutions.co.uk; ManufacturerName: DolphinsolutionsLimited; ManufacturerURL: http://www.dolphinsolutions.co.uk/; Material: StainlessSteel; ModelNumber: BC5063-01; ModelReference: DolphinSolutionsLimited_Roseless32mmGrabRail; Name: SupportRails_Roseless32mmGrabRail_BC5063-01_DolphinSolutionsLimited; NBSDescription: Support rails; NBSReference: 45-35-72/360; NBSTypeID: n/a; NominalHeight: 92 mm; NominalLength: 450 mm; NominalWidth: 32 mm; ObjectClassification_1: OmniClass; ObjectClassification_2: 23.40.20.27.14; ProductInformation: https://www.dolphinsolutions.co.uk/product/dolphin-roseless-stainless-steel-grab-rail-32mm/; ReplacementCost: n/a; Revision: n/a; SerialNumber: n/a; Shape: n/a; Size: 450 x 32 x 92 mm; SustainabilityPerformance: n/a; TagNumber: n/a; Type Name: Standard; Uniclass2015Code: Pr_40_20_76_84; Uniclass2015Title: Support rails; WarrantyDescription: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a; WarrantyStartDate: 31-12-1900 23:59
Dimensions(Type) - Depth: 76 mm; Diameter: 32 mm; Width: 450 mm
Constraints(Type) - Default Elevation: 1219.2 mm

# IfcFlowTerminal: BC5063-02:Standard (3)
In: Level 1
Pset_DistributionFlowElementCommon - Reference: BC5063-02:Standard; sets with these values: 2
Pset_ElementShading - Color: Brushed Satin
Pset_ManufacturerOccurrence - BarCode: n/a; SerialNumber: n/a
Pset_ManufacturerTypeInformation - ModelReference: DolphinSolutionsLimited_Roseless32mmGrabRail; Manufacturer: mailto:info@dolphinsolutions.co.uk
Pset_ProductRequirements - Name: SupportRails_Roseless32mmGrabRail_BC5063-02_DolphinSolutionsLimited; Category: Plumbing Fixtures
Constraints - Level: Level: Level 1; Moves With Nearby Elements: no; Host: Level : Level 1
Dimensions - Area: 0.0662086 m2; Volume: 0.00013204 m3
Other - Category: Plumbing Fixtures; Family: BC5063-02: Standard; Family and Type: BC5063-02: Standard; Type: BC5063-02: Standard; Type Id: BC5063-02: Standard
Phasing - Phase Created: Phase 1
Other(Type) - Category: Plumbing Fixtures; Family Name: BC5063-02
Identity Data(Type) - AccessibilityPerformance: n/a; AssetIdentifier: n/a; AssetType: Fixed; BarCode: n/a; Category: Pr_40_20_76_84:SupportRails; CodePerformance: BSEN12182; Color: Brushed Satin; Constituents: n/a; Description: 600mm long roseless 32mm grab rail; DurationUnit: year; ExpectedLife: n/a; Features: Roseless 60mm wall clearance; Finish: Brushed Satin; Form: Wall-mounted; Grade: 304; InstallationDate: 31-12-1900 23:59; Manufacturer: mailto:info@dolphinsolutions.co.uk; ManufacturerName: DolphinsolutionsLimited; ManufacturerURL: http://www.dolphinsolutions.co.uk/; Material: StainlessSteel; ModelNumber: BC5063-02; ModelReference: DolphinSolutionsLimited_Roseless32mmGrabRail; Name: SupportRails_Roseless32mmGrabRail_BC5063-02_DolphinSolutionsLimited; NBSDescription: Support rails; NBSReference: 45-35-72/360; NBSTypeID: n/a; NominalHeight: 92 mm; NominalLength: 600 mm; NominalWidth: 32 mm; ObjectClassification_1: OmniClass; ObjectClassification_2: 23.40.20.27.14; ProductInformation: https://www.dolphinsolutions.co.uk/product/dolphin-roseless-stainless-steel-grab-rail-32mm/; ReplacementCost: n/a; Revision: n/a; SerialNumber: n/a; Shape: n/a; Size: 600 x 32 x 92 mm; SustainabilityPerformance: n/a; TagNumber: n/a; Type Name: Standard; Uniclass2015Code: Pr_40_20_76_84; Uniclass2015Title: Support rails; WarrantyDescription: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a; WarrantyStartDate: 31-12-1900 23:59
Dimensions(Type) - Depth: 76 mm; Diameter: 32 mm; Width: 600 mm
Constraints(Type) - Default Elevation: 1219.2 mm
Name (BC5063-02:Standard:...) | Elevation from Level (mm) = Offset from Host (mm) | Mark
495758 | 665 | 106
495760 | 665 | 108
495765 | 1100 | 113

# IfcFlowTerminal: BC5083-04PSS/BC5083-25, BC5083-04PSS-BC5083-25:BC5083-04PSS/BC5083-25:496110
In: Level 1
Type - PredefinedType: USERDEFINED
Type - Constraints - Default Elevation: 0 mm
Type - Dimensions - Height: 900 mm
Type - Identity Data - AccessibilityPerformance: n/a; AssetIdentifier: n/a; AssetType: Fixed; BarCode: n/a; Category: Pr_40_20_87_75:Shower fittings package; CodePerformance: BS EN 12182; Color: MirrorPolished; Constituents: n/a; Description: Shower riser rail and bracket; DurationUnit: year; ExpectedLife: n/a; Features: n/a; Finish: Polished; Grade: 304; IfcExportAs: IfcSanitaryTerminalType; IfcExportType: USERDEFINED; InstallationDate: 31-12-1900 23:59; Manufacturer: info@dolphinsolutions.co.uk; ManufacturerName: DolphinsolutionsLimited; ManufacturerURL: http://www.dolphinsolutions.co.uk/; Material: StainlessSteel; ModelNumber: BC5083-04PSS/BC5083-25; ModelReference: ShowerFittingsPackage_DolphinSolutionsLimited_WRAS_BC5083-04PSS/BC5083-25; Name: ShowerFittingsPackage_WRAS_BC5083-04PSS/BC5083-25_ShowerRiserRailAndBracket_DolphinSolutionsLimited; NBSDescription: Showers; NBSReference: 45-35-70/333; NominalHeight: 92 mm; NominalLength: 900 mm; NominalWidth: 32 mm; ObjectClassification1: OmniClass; ObjectClassification2: 23.45.05.14.17; OmniClass Number: 23.45.00.00; OmniClass Title: Sanitary, Laundry, and Cleaning Equipment; Product Information: https://www.dolphinsolutions.co.uk/product/8173/; ReplacementCost: n/a; Shape: n/a; Size: 32x900x92; SustainabilityPerformance: n/a; TagNumber: n/a; Type Name: BC5083-04PSS/BC5083-25; Uniclass2015Code: Pr_40_20_87_75; Uniclass2015Title: Shower fittings package; WarrantyDescription: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: year; WarrantyGuarantorLabor: DolphinSolutionsLimited; WarrantyGuarantorParts: DolphinSolutionsLimited; WarrantyStartDate: 31-12-1900 23:59
Type - Other - Category: Plumbing Fixtures; Family Name: BC5083-04PSS-BC5083-25
Type - Pset_SanitaryTerminalTypeBath - Color: MirrorPolished
Type - Pset_SanitaryTerminalTypeBidet - Color: MirrorPolished
Type - Pset_SanitaryTerminalTypeSanitaryFountain - Color: MirrorPolished
Type - Pset_SanitaryTerminalTypeShower - Color: MirrorPolished
Type - Pset_SanitaryTerminalTypeSink - Color: MirrorPolished
Type - Pset_SanitaryTerminalTypeWashHandBasin - Color: MirrorPolished
Pset_DistributionFlowElementCommon - Reference: BC5083-04PSS-BC5083-25:BC5083-04PSS/BC5083-25; sets with these values: 2
Pset_ElementShading - Color: MirrorPolished
Pset_ManufacturerOccurrence - BarCode: n/a
Pset_ManufacturerTypeInformation - ModelReference: ShowerFittingsPackage_DolphinSolutionsLimited_WRAS_BC5083-04PSS/BC5083-25; Manufacturer: info@dolphinsolutions.co.uk
Pset_ProductRequirements - Name: ShowerFittingsPackage_WRAS_BC5083-04PSS/BC5083-25_ShowerRiserRailAndBracket_DolphinSolutionsLimited; Category: Plumbing Fixtures
Constraints - Level: Level: Level 1; Moves With Nearby Elements: no; Elevation from Level: 850 mm; Host: Level : Level 1; Offset from Host: 850 mm
Dimensions - Area: 0.0787353 m2; Volume: 0.0010624 m3
Identity Data - Mark: 423
Other - Family: BC5083-04PSS-BC5083-25: BC5083-04PSS/BC5083-25; Family and Type: BC5083-04PSS-BC5083-25: BC5083-04PSS/BC5083-25; Type: BC5083-04PSS-BC5083-25: BC5083-04PSS/BC5083-25; Type Id: BC5083-04PSS-BC5083-25: BC5083-04PSS/BC5083-25
Phasing - Phase Created: Phase 1

# IfcFlowTerminal: BC5083-101:Standard, BC5083-101:Standard:495762
In: Level 1
Other(Type) - Category: Plumbing Fixtures; Family Name: BC5083-101
Identity Data(Type) - AccessibilityPerformance: n/a; AssetIdentifier: n/a; AssetType: Fixed; BarCode: n/a; Category: Pr_25_71_53_06:Bathroom mirrors; CodePerformance: n/a; Color: n/a; Constituents: n/a; Description: Wall-mounted mirror; DurationUnit: year; ExpectedLife: n/a; Features: n/a; Finish: n/a; Form: Wall-mounted; Grade: n/a; InstallationDate: 31-12-1900 23:59; Manufacturer: mailto:info@dolphinsolutions.co.uk; ManufacturerName: DolphinsolutionsLimited; ManufacturerURL: http://www.dolphinsolutions.co.uk/; Material: Glass; ModelNumber: BC5083-101; ModelReference: DolphinSolutionsLimited_Mirror; Name: BathroomMirrors_Mirror_BC5083-101_DolphinSolutionsLimited; NBSDescription: Bathroom mirrors; NBSReference: 45-35-72/336; NBSTypeID: n/a; NominalHeight: 1000; NominalLength: 15; NominalWidth: 400; ObjectClassification_1: OmniClass; ObjectClassification_2: 23.40.95.17.17; OmniClass Number: 23.45.05.21.11; OmniClass Title: Water Closets; ReplacementCost: n/a; Revision: n/a; SerialNumber: n/a; Shape: Rectangular; Size: 400 x 1000 x 15 mm; SustainabilityPerformance: n/a; TagNumber: n/a; Type Name: Standard; Uniclass2015Code: Pr_25_71_53_06; Uniclass2015Title: Bathroom mirrors; WarrantyDescription: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a; WarrantyStartDate: 31-12-1900 23:59
Dimensions(Type) - Depth: 10 mm; Height: 1000 mm; Width: 400 mm
Constraints(Type) - Default Elevation: 0 mm
Pset_DistributionFlowElementCommon - Reference: BC5083-101:Standard; sets with these values: 2
Pset_ElementShading - Color: n/a
Pset_ManufacturerOccurrence - BarCode: n/a; SerialNumber: n/a
Pset_ManufacturerTypeInformation - ModelReference: DolphinSolutionsLimited_Mirror; Manufacturer: mailto:info@dolphinsolutions.co.uk
Pset_ProductRequirements - Name: BathroomMirrors_Mirror_BC5083-101_DolphinSolutionsLimited; Category: Plumbing Fixtures
Constraints - Level: Level: Level 1; Moves With Nearby Elements: no; Elevation from Level: 600 mm; Host: Level : Level 1; Offset from Host: 600 mm
Dimensions - Area: 0.827875 m2; Volume: 0.004 m3
Identity Data - Mark: 110
Other - Category: Plumbing Fixtures; Family: BC5083-101: Standard; Family and Type: BC5083-101: Standard; Type: BC5083-101: Standard; Type Id: BC5083-101: Standard
Phasing - Phase Created: Phase 1

# IfcFlowTerminal: BC5083-121:Standard, BC5083-121:Standard:495761
In: Level 1
Other(Type) - Category: Plumbing Fixtures; Family Name: BC5083-121
Identity Data(Type) - AccessibilityPerformance: n/a; AssetIdentifier: n/a; AssetType: Fixed; BarCode: n/a; Category: Pr_75_75_04_04:AssistanceCallPulCordUnits; CodePerformance: BS8300:DocM; Color: Brushed Satin; Constituents: n/a; Description: Ceiling fitted assistance call pull cord unit with wall mounted reset; DurationUnit: year; ExpectedLife: n/a; Features: BS8300:DocM_PullCord_OpenDoorIndicator_ResetButton; Finish: Brushed Satin; Form: Surface-mounted; Grade: 304; InstallationDate: 31-12-1900 23:59; Manufacturer: mailto:info@dolphinsolutions.co.uk; ManufacturerName: DolphinsolutionsLimited; ManufacturerURL: http://www.dolphinsolutions.co.uk/; Material: StainlessSteel; ModelNumber: BC5083-121; ModelReference: DolphinSolutionsLimited_AssistanceCallPulCordUnit; Name: AssistanceCallPulCordUnits_AssistanceCallPulCordUnit_BC5083-121_DolphinSolutionsLimited; NBSDescription: AssistanceCallPulCordUnits; NBSReference: 90-70-05/320; NBSTypeID: n/a; NominalHeight: 0; NominalLength: 0; NominalWidth: 0; ObjectClassification_1: OmniClass; ObjectClassification_2: 23.85.30.24.11; Operation: PullCord; ProductInformation: https://www.nationalbimlibrary.com/en-gb/vox-ignis-limited/vilx-cpp-assist-call-pull-cord-plate/?lo=en-GB; ReplacementCost: n/a; Revision: n/a; SerialNumber: n/a; Shape: n/a; Size: n/a; SustainabilityPerformance: n/a; TagNumber: n/a; Type Name: Standard; Uniclass2015Code: Pr_75_75_04_04; Uniclass2015Title: AssistanceCallPulCordUnits; Uniclass2015Version: Products v1.15; Version: 1; WarrantyDescription: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a; WarrantyStartDate: 31-12-1900 23:59
Dimensions(Type) - Height: 2500 mm
Constraints(Type) - Default Elevation: 0 mm
Pset_DistributionFlowElementCommon - Reference: BC5083-121:Standard; sets with these values: 2
Pset_ElementShading - Color: Brushed Satin
Pset_ManufacturerOccurrence - BarCode: n/a; SerialNumber: n/a
Pset_ManufacturerTypeInformation - ModelReference: DolphinSolutionsLimited_AssistanceCallPulCordUnit; Manufacturer: mailto:info@dolphinsolutions.co.uk
Pset_ProductRequirements - Name: AssistanceCallPulCordUnits_AssistanceCallPulCordUnit_BC5083-121_DolphinSolutionsLimited; Category: Plumbing Fixtures
Constraints - Level: Level: Level 1; Moves With Nearby Elements: no; Elevation from Level: 0 mm; Host: Level : Level 1; Offset from Host: 0 mm
Dimensions - Area: 0.0221672 m2; Volume: 0.000127718 m3
Identity Data - Mark: 109
Other - Category: Plumbing Fixtures; Family: BC5083-121: Standard; Family and Type: BC5083-121: Standard; Type: BC5083-121: Standard; Type Id: BC5083-121: Standard
Phasing - Phase Created: Phase 1

# IfcFlowTerminal: BC5083-16, BC5083-16:BC5083-16:496114
In: Level 1
Type - PredefinedType: SHOWER
Type - Constraints - Default Elevation: 0 mm
Type - Identity Data - AccessibilityPerformance: n/a; AssetIdentifier: n/a; AssetType: Fixed; BarCode: n/a; Category: Pr_40_20_87_75:Shower fittings package; CodePerformance: WRAS; Color: Chrome; Constituents: n/a; Description: Two way diverter; DurationUnit: year; ExpectedLife: n/a; Features: 1/2"BSP_connection; Finish: Chrome; IfcExportAs: IfcSanitaryTerminalType; IfcExportType: SHOWER; InstallationDate: 31-12-1900 23:59; Manufacturer: info@dolphinsolutions.co.uk; ManufacturerName: DolphinsolutionsLimited; ManufacturerURL: http://www.dolphinsolutions.co.uk/; Material: Body/ChromePlatedPolishedBrass_Lever/ChromePlatedZincDieCast; ModelNumber: BC5083-16; ModelReference: ShowerFittingsPackages_DolphinSolutionsLimited_WRAS_BC5083-16; Name: ShowerFittingsPackages_WRAS_BC5083-16_TwoWayDiverter_DolphinSolutionsLimited; NBSDescription: Showers; NBSReference: 45-35-70/333; NominalHeight: 47 mm; NominalLength: 70 mm; NominalWidth: 70 mm; ObjectClassification1: OmniClass; ObjectClassification2: 23.45.05.14.17; OmniClass Number: 23.45.00.00; OmniClass Title: Sanitary, Laundry, and Cleaning Equipment; ReplacementCost: n/a; Shape: Round; Size: 70x70x47 mm; SustainabilityPerformance: n/a; TagNumber: n/a; Type Name: BC5083-16; Uniclass2015Code: Pr_40_20_87_75; Uniclass2015Title: Shower fittings package; WarrantyDescription: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: year; WarrantyGuarantorLabor: DolphinSolutionsLimited; WarrantyGuarantorParts: DolphinSolutionsLimited; WarrantyStartDate: 31-12-1900 23:59
Type - Other - Category: Plumbing Fixtures; Family Name: BC5083-16
Type - Pset_SanitaryTerminalTypeBath - Color: Chrome
Type - Pset_SanitaryTerminalTypeBidet - Color: Chrome
Type - Pset_SanitaryTerminalTypeSanitaryFountain - Color: Chrome
Type - Pset_SanitaryTerminalTypeShower - Color: Chrome
Type - Pset_SanitaryTerminalTypeSink - Color: Chrome
Type - Pset_SanitaryTerminalTypeWashHandBasin - Color: Chrome
Pset_DistributionFlowElementCommon - Reference: BC5083-16:BC5083-16; sets with these values: 2
Pset_ElementShading - Color: Chrome
Pset_ManufacturerOccurrence - BarCode: n/a
Pset_ManufacturerTypeInformation - ModelReference: ShowerFittingsPackages_DolphinSolutionsLimited_WRAS_BC5083-16; Manufacturer: info@dolphinsolutions.co.uk
Pset_ProductRequirements - Name: ShowerFittingsPackages_WRAS_BC5083-16_TwoWayDiverter_DolphinSolutionsLimited; Category: Plumbing Fixtures
Constraints - Level: Level: Level 1; Moves With Nearby Elements: no; Elevation from Level: 900 mm; Host: Level : Level 1; Offset from Host: 900 mm
Dimensions - Area: 0.0144412 m2; Volume: 0.000126831 m3
Identity Data - Mark: 427
Other - Family: BC5083-16: BC5083-16; Family and Type: BC5083-16: BC5083-16; Type: BC5083-16: BC5083-16; Type Id: BC5083-16: BC5083-16
Phasing - Phase Created: Phase 1

# IfcFlowTerminal: BC5083-18, BC5083-18:BC5083-18:496113
In: Level 1
Type - PredefinedType: USERDEFINED
Type - Constraints - Default Elevation: 0 mm
Type - Dimensions - Height: 800 mm
Type - Identity Data - AccessibilityPerformance: n/a; AssetIdentifier: n/a; AssetType: Fixed; BarCode: n/a; Category: Pr_40_20_87_75:Shower fittings package; CodePerformance: WRAS; Constituents: n/a; Description: Copper Tube; DurationUnit: year; ExpectedLife: n/a; Features: n/a; Finish: n/a; Grade: n/a; IfcExportAs: IfcSanitaryTerminalType; IfcExportType: USERDEFINED; InstallationDate: 31-12-1900 23:59; Manufacturer: info@dolphinsolutions.co.uk; ManufacturerName: DolphinsolutionsLimited; ManufacturerURL: http://www.dolphinsolutions.co.uk/; Material: Copper; ModelNumber: BC5083-18; ModelReference: ShowerFittingsPackage_DolphinSolutionsLimited_WRAS_BC5083-18; Name: ShowerFittingsPackage_WRAS_BC5083-18_ShowerArm_DolphinSolutionsLimited; NBSDescription: Showers; NBSReference: 45-35-70/333; NominalHeight: 0; NominalLength: n/a; NominalWidth: 0; ObjectClassification1: OmniClass; ObjectClassification2: 23.45.05.14.17; ReplacementCost: n/a; Shape: n/a; Size: n/a; SustainabilityPerformance: n/a; TagNumber: n/a; Type Name: BC5083-18; Uniclass2015Code: Pr_40_20_87_75; Uniclass2015Title: Shower fittings package; WarrantyDescription: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: year; WarrantyGuarantorLabor: DolphinSolutionsLimited; WarrantyGuarantorParts: DolphinSolutionsLimited; WarrantyStartDate: 31-12-1900 23:59
Type - Other - Category: Plumbing Fixtures; Family Name: BC5083-18
Pset_DistributionFlowElementCommon - Reference: BC5083-18:BC5083-18; sets with these values: 2
Pset_ManufacturerOccurrence - BarCode: n/a
Pset_ManufacturerTypeInformation - ModelReference: ShowerFittingsPackage_DolphinSolutionsLimited_WRAS_BC5083-18; Manufacturer: info@dolphinsolutions.co.uk
Pset_ProductRequirements - Name: ShowerFittingsPackage_WRAS_BC5083-18_ShowerArm_DolphinSolutionsLimited; Category: Plumbing Fixtures
Constraints - Level: Level: Level 1; Moves With Nearby Elements: no; Elevation from Level: 944.542 mm; Host: Level : Level 1; Offset from Host: 944.542 mm
Dimensions - Area: 0.0339928 m2; Volume: 0.0000508914 m3
Identity Data - Mark: 426
Other - Family: BC5083-18: BC5083-18; Family and Type: BC5083-18: BC5083-18; Type: BC5083-18: BC5083-18; Type Id: BC5083-18: BC5083-18
Phasing - Phase Created: Phase 1

# IfcFlowTerminal: BC5083-24, BC5083-24:BC5083-24:496112
In: Level 1
Type - PredefinedType: SHOWER
Type - Constraints - Default Elevation: 0 mm
Type - Identity Data - AccessibilityPerformance: n/a; AssetIdentifier: n/a; AssetType: Fixed; BarCode: n/a; Category: Pr_40_20_87_76:Shower heads; CodePerformance: WRAS; Color: Chrome; Constituents: n/a; Description: Shower handset and hose; DurationUnit: year; ExpectedLife: n/a; Finish: ChromePlated; IfcExportAs: IfcSanitaryTerminalType; IfcExportType: SHOWER; InstallationDate: 31-12-1900 23:59; Manufacturer: info@dolphinsolutions.co.uk; ManufacturerName: DolphinsolutionsLimited; ManufacturerURL: http://www.dolphinsolutions.co.uk/; ModelNumber: BC5083-24; ModelReference: ShowerHeads_DolphinSolutionsLimited_WRAS_BC5083-24; Name: ShowerHeads_WRAS_BC5083-24_ShowerHandsetAndHose_DolphinSolutionsLimited; NBSDescription: Showers; NBSReference: 45-35-70/333; ObjectClassification1: OmniClass; ObjectClassification2: 23.45.05.14.17; OmniClass Number: 23.45.00.00; OmniClass Title: Sanitary, Laundry, and Cleaning Equipment; ReplacementCost: n/a; SustainabilityPerformance: n/a; TagNumber: n/a; Type Name: BC5083-24; Uniclass2015Code: Pr_40_20_87_76; Uniclass2015Title: Shower heads; WarrantyDescription: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: year; WarrantyGuarantorLabor: DolphinSolutionsLimited; WarrantyGuarantorParts: DolphinSolutionsLimited; WarrantyStartDate: 31-12-1900 23:59
Type - Other - Category: Plumbing Fixtures; Family Name: BC5083-24
Type - Pset_SanitaryTerminalTypeBath - Color: Chrome
Type - Pset_SanitaryTerminalTypeBidet - Color: Chrome
Type - Pset_SanitaryTerminalTypeSanitaryFountain - Color: Chrome
Type - Pset_SanitaryTerminalTypeShower - Color: Chrome
Type - Pset_SanitaryTerminalTypeSink - Color: Chrome
Type - Pset_SanitaryTerminalTypeWashHandBasin - Color: Chrome
Pset_DistributionFlowElementCommon - Reference: BC5083-24:BC5083-24; sets with these values: 2
Pset_ElementShading - Color: Chrome
Pset_ManufacturerOccurrence - BarCode: n/a
Pset_ManufacturerTypeInformation - ModelReference: ShowerHeads_DolphinSolutionsLimited_WRAS_BC5083-24; Manufacturer: info@dolphinsolutions.co.uk
Pset_ProductRequirements - Name: ShowerHeads_WRAS_BC5083-24_ShowerHandsetAndHose_DolphinSolutionsLimited; Category: Plumbing Fixtures
Constraints - Level: Level: Level 1; Moves With Nearby Elements: no; Elevation from Level: 1370.07 mm; Host: Level : Level 1; Offset from Host: 1370.07 mm
Dimensions - Area: 0.0392493 m2; Volume: 0.000424589 m3
Identity Data - Mark: 425
Other - Family: BC5083-24: BC5083-24; Family and Type: BC5083-24: BC5083-24; Type: BC5083-24: BC5083-24; Type Id: BC5083-24: BC5083-24
Phasing - Phase Created: Phase 1

# IfcFlowTerminal: BC725:BC725 (2)
In: Level 1
Pset_DistributionFlowElementCommon - Reference: BC725:BC725; sets with these values: 2
Pset_ElementShading - Color: Brushed Satin or RALPowderCoated
Pset_ManufacturerOccurrence - BarCode: n/a; SerialNumber: n/a
Pset_ManufacturerTypeInformation - ModelReference: DolphinSolutionsLimited_ClothesHooks; Manufacturer: mailto:info@dolphinsolutions.co.uk
Pset_ProductRequirements - Name: Clothes hooks_BC725_DolphinSolutionsLimited; Category: Plumbing Fixtures
Constraints - Level: Level: Level 1; Moves With Nearby Elements: no; Host: Level : Level 1
Dimensions - Area: 0.00466682 m2; Volume: 0.0000330174 m3
Other - Category: Plumbing Fixtures; Family: BC725: BC725; Family and Type: BC725: BC725; Type: BC725: BC725; Type Id: BC725: BC725
Phasing - Phase Created: Phase 1
Other(Type) - Category: Plumbing Fixtures; Family Name: BC725
Identity Data(Type) - AccessibilityPerformance: n/a; AssetIdentifier: n/a; AssetType: Fixed; BarCode: n/a; Category: Pr_40_30_78_15:Clothes hooks; CodePerformance: n/a; Color: Brushed Satin or RALPowderCoated; Constituents: n/a; Description: Clothes hooks; DurationUnit: year; ExpectedLife: n/a; Features: n/a; Finish: Brushed Satin or RALPowderCoated; Form: Wall-mounted; Grade: 304; InstallationDate: 31-12-1900 23:59; Manufacturer: mailto:info@dolphinsolutions.co.uk; ManufacturerName: DolphinsolutionsLimited; ManufacturerURL: http://www.dolphinsolutions.co.uk/; Material: StainlessSteel; ModelNumber: BC725/BC725PC; ModelReference: DolphinSolutionsLimited_ClothesHooks; Name: Clothes hooks_BC725_DolphinSolutionsLimited; NBSDescription: Clothes hooks; NBSReference: 45-35-72/322; NBSTypeID: n/a; NominalHeight: 0; NominalLength: 60; NominalWidth: 48; ObjectClassification_1: OmniClass; ObjectClassification_2: 23.40.20.21.31; OmniClass Number: 23.45.00.00; OmniClass Title: Sanitary, Laundry, and Cleaning Equipment; ProductInformation: https://www.dolphinsolutions.co.uk/product/single-robe-hook-bc725/; ReplacementCost: n/a; Revision: n/a; SerialNumber: n/a; Shape: n/a; Size: 60 x 48 mm; SustainabilityPerformance: n/a; TagNumber: n/a; Type Name: BC725; Uniclass2015Code: Pr_40_30_78_15; Uniclass2015Title: Clothes hooks; WarrantyDescription: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a; WarrantyStartDate: 31-12-1900 23:59
Constraints(Type) - Default Elevation: 0 mm
Name (BC725:BC725:...) | Elevation from Level (mm) = Offset from Host (mm) | Mark
495756 | 1400 | 104
495764 | 1050 | 112

# IfcFlowTerminal: DB1032, DB1032:DB1032:496111
In: Level 1
Type - PredefinedType: SHOWER
Type - Constraints - Default Elevation: 0 mm
Type - Identity Data - AccessibilityPerformance: n/a; AssetIdentifier: n/a; AssetType: Fixed; BarCode: n/a; Category: Pr_40_20_87_76:Shower heads; CodePerformance: WRAS; Color: Chrome; Constituents: n/a; Description: Shower head wall mounted bottom inlet; DurationUnit: year; ExpectedLife: n/a; Features: Easy clean silicone nozzles; Finish: ChromePlated; IfcExportAs: IfcSanitaryTerminalType; IfcExportType: SHOWER; InstallationDate: 31-12-1900 23:59; Manufacturer: info@dolphinsolutions.co.uk; ManufacturerName: DolphinsolutionsLimited; ManufacturerURL: http://www.dolphinsolutions.co.uk/; Material: ChromePlatedBrass; ModelNumber: DB1032 DB1032 DB1032 DB1032 DB1032; ModelReference: ShowerHeads_DolphinSolutionsLimited_WRAS_DB1032; Name: ShowerHeads_WRAS_DB1032_ShowerHeadWallMountedBottomInlet_DolphinSolutionsLimited; NBSDescription: Showers; NBSReference: 45-35-70/333; NominalHeight: 98 mm; NominalWidth: 62 mm; ObjectClassification1: OmniClass; ObjectClassification2: 23.45.05.14.17; Product Information: https://www.dolphinsolutions.co.uk/product/dolphin-shower-head-wall-mounted-bottom-inlet/; ReplacementCost: n/a; Size: 62x98; SustainabilityPerformance: n/a; TagNumber: n/a; Type Name: DB1032; Uniclass2015Code: Pr_40_20_87_76; Uniclass2015Title: Shower heads; WarrantyDescription: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: 2; WarrantyDurationUnit: year; WarrantyGuarantorLabor: DolphinSolutionsLimited; WarrantyGuarantorParts: DolphinSolutionsLimited; WarrantyStartDate: 31-12-1900 23:59
Type - Other - Category: Plumbing Fixtures; Family Name: DB1032
Type - Pset_SanitaryTerminalTypeBath - Color: Chrome
Type - Pset_SanitaryTerminalTypeBidet - Color: Chrome
Type - Pset_SanitaryTerminalTypeSanitaryFountain - Color: Chrome
Type - Pset_SanitaryTerminalTypeShower - Color: Chrome
Type - Pset_SanitaryTerminalTypeSink - Color: Chrome
Type - Pset_SanitaryTerminalTypeWashHandBasin - Color: Chrome
Pset_DistributionFlowElementCommon - Reference: DB1032:DB1032; sets with these values: 2
Pset_ElementShading - Color: Chrome
Pset_ManufacturerOccurrence - BarCode: n/a
Pset_ManufacturerTypeInformation - ModelReference: ShowerHeads_DolphinSolutionsLimited_WRAS_DB1032; Manufacturer: info@dolphinsolutions.co.uk
Pset_ProductRequirements - Name: ShowerHeads_WRAS_DB1032_ShowerHeadWallMountedBottomInlet_DolphinSolutionsLimited; Category: Plumbing Fixtures
Constraints - Level: Level: Level 1; Moves With Nearby Elements: no; Elevation from Level: 1763.64 mm; Host: Level : Level 1; Offset from Host: 1763.64 mm
Dimensions - Area: 0.0152555 m2; Volume: 0.000199959 m3
Identity Data - Mark: 424
Other - Family: DB1032: DB1032; Family and Type: DB1032: DB1032; Type: DB1032: DB1032; Type Id: DB1032: DB1032
Phasing - Phase Created: Phase 1

# IfcFurnishingElement: BC5083-11, BC5083-11:BC5083-11:495753
In: Level 1
Type - Constraints - Default Elevation: 0 mm
Type - Dimensions - Length: 1200 mm
Type - Identity Data - AccessibilityPerformance: n/a; AssetIdentifier: n/a; AssetType: Fixed; BarCode: n/a; Category: Pr_40_30_20_77:Shower curtain rails; CodePerformance: n/a; Color: BrushedSatin_Polished_PVD_RAL_PowderCoated_CeramicCoated; Constituents: n/a; Description: Shower curtain rails; DurationUnit: year; ExpectedLife: n/a; Features: Concealed fixings; Finish: Suffix_.1BrushedSatin_.2Polished_.3PVD_.5PowderCoated_.6CeramicCoated; Grade: 304; IfcExportAs: IfcFurnitureType; IfcExportType: USERDEFINED; InstallationDate: 31-12-1900 23:59; Manufacturer: info@dolphinsolutions.co.uk; ManufacturerName: DolphinsolutionsLimited; ManufacturerURL: http://www.dolphinsolutions.co.uk/; Material: StainlessSteel; ModelNumber: BC5083-11; ModelReference: ShowerCurtainRails_DolphinSolutionsLimited_BC5083-11; Name: ShowerCurtainRails_BC5083-11_ShowerCurtainRail_DolphinSolutionsLimited; NBSDescription: Shower curtain rails; NBSReference: 45-35-70/334; NominalLength: 1200 mm; NominalWidth: 1200 mm; ObjectClassification1: OmniClass; ObjectClassification2: 23.45.05.14.17; OmniClass Number: 23.40.20.21.44; OmniClass Title: Shower Rods, Curtains; Product Information: https://www.dolphinsolutions.co.uk/product/dolphin-corner-shower-rail/; ReplacementCost: n/a; Size: 1200x1200; SustainabilityPerformance: n/a; TagNumber: n/a; Type Name: BC5083-11; Uniclass2015Code: Pr_40_30_20_77; Uniclass2015Title: Shower curtain rails; WarrantyDescription: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: year; WarrantyGuarantorLabor: DolphinSolutionsLimited; WarrantyGuarantorParts: DolphinSolutionsLimited; WarrantyStartDate: 31-12-1900 23:59
Type - Other - Category: Plumbing Fixtures; Family Name: BC5083-11
Type - Pset_FurnitureTypeCommon - Description: Shower curtain rails
Pset_ElementShading - Color: BrushedSatin_Polished_PVD_RAL_PowderCoated_CeramicCoated
Pset_ManufacturerOccurrence - BarCode: n/a
Pset_ManufacturerTypeInformation - ModelReference: ShowerCurtainRails_DolphinSolutionsLimited_BC5083-11; Manufacturer: info@dolphinsolutions.co.uk
Pset_ProductRequirements - Name: ShowerCurtainRails_BC5083-11_ShowerCurtainRail_DolphinSolutionsLimited; Category: Plumbing Fixtures
Pset_QuantityTakeOff - Reference: BC5083-11:BC5083-11
Constraints - Elevation from Level: 2025 mm; Host: Level : Level 1; Level: Level: Level 1; Moves With Nearby Elements: no; Offset from Host: 2025 mm
Dimensions - Area: 0.10303 m2; Volume: 0.00124196 m3
Identity Data - Mark: 101
Other - Family: BC5083-11: BC5083-11; Family and Type: BC5083-11: BC5083-11; Type: BC5083-11: BC5083-11; Type Id: BC5083-11: BC5083-11
Phasing - Phase Created: Phase 1

# IfcFurnishingElement: BC5083-12, BC5083-12:BC5083-12:495766
In: Level 1
Type - Constraints - Default Elevation: 0 mm
Type - Identity Data - AccessibilityPerformance: n/a; AssetIdentifier: n/a; AssetType: Fixed; BarCode: n/a; Category: Pr_40_30_20_77:Shower curtain rails; CodePerformance: n/a; Color: BrushedSatin_Polished_PVD_RAL_PowderCoated_CeramicCoated; Constituents: n/a; Description: Shower curtain rail ceiling stay; DurationUnit: year; ExpectedLife: n/a; Features: Concealed fixings; Finish: Suffix_.1BrushedSatin_.2Polished_.3PVD_.5PowderCoated_.6CeramicCoated; Grade: 304; IfcExportAs: IfcFurnitureType; IfcExportType: USERDEFINED; InstallationDate: 31-12-1900 23:59; Manufacturer: info@dolphinsolutions.co.uk; ManufacturerName: DolphinsolutionsLimited; ManufacturerURL: http://www.dolphinsolutions.co.uk/; Material: StainlessSteel; ModelNumber: BC5083-12; ModelReference: ShowerCurtainRails_CeilingStay_DolphinSolutionsLimited_BC5083-12; Name: ShowerCurtainRails_BC5083-12_ShowerCurtainRailCeilingStay_DolphinSolutionsLimited; NBSDescription: Shower curtain rails; NBSReference: 45-35-70/334; NominalHeight: 500 mm; NominalWidth: 75 mm; ObjectClassification1: OmniClass; ObjectClassification2: 23.45.05.14.17; OmniClass Number: 23.40.20.21.44; OmniClass Title: Shower Rods, Curtains; Product Information: https://www.dolphinsolutions.co.uk/product/dolphin-ceiling-stay/; ReplacementCost: n/a; Size: 75x500; SustainabilityPerformance: n/a; TagNumber: n/a; Type Name: BC5083-12; Uniclass2015Code: Pr_40_30_20_77; Uniclass2015Title: Shower curtain rails; WarrantyDescription: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: year; WarrantyGuarantorLabor: DolphinSolutionsLimited; WarrantyGuarantorParts: DolphinSolutionsLimited; WarrantyStartDate: 31-12-1900 23:59
Type - Other - Category: Plumbing Fixtures; Family Name: BC5083-12
Type - Pset_FurnitureTypeCommon - Description: Shower curtain rail ceiling stay
Pset_ElementShading - Color: BrushedSatin_Polished_PVD_RAL_PowderCoated_CeramicCoated
Pset_ManufacturerOccurrence - BarCode: n/a
Pset_ManufacturerTypeInformation - ModelReference: ShowerCurtainRails_CeilingStay_DolphinSolutionsLimited_BC5083-12; Manufacturer: info@dolphinsolutions.co.uk
Pset_ProductRequirements - Name: ShowerCurtainRails_BC5083-12_ShowerCurtainRailCeilingStay_DolphinSolutionsLimited; Category: Plumbing Fixtures
Pset_QuantityTakeOff - Reference: BC5083-12:BC5083-12
Constraints - Level: Level: Level 1; Moves With Nearby Elements: no; Elevation from Level: 2500 mm; Host: Level : Level 1; Offset from Host: 2500 mm
Dimensions - Area: 0.00895278 m2; Volume: 0.0000298871 m3
Identity Data - Mark: 114
Other - Family: BC5083-12: BC5083-12; Family and Type: BC5083-12: BC5083-12; Type: BC5083-12: BC5083-12; Type Id: BC5083-12: BC5083-12
Phasing - Phase Created: Phase 1

# IfcFurnishingElement: BC5083-13 (24)
In: Level 1
Type - Constraints - Default Elevation: 0 mm
Type - Identity Data - AccessibilityPerformance: n/a; AssetIdentifier: n/a; AssetType: Fixed; BarCode: n/a; CodePerformance: n/a; Color: Chrome; Constituents: n/a; Description: Shower curtain hooks; DurationUnit: year; ExpectedLife: n/a; Features: n/a; Finish: Chrome Plated; Grade: 304; IfcExportAs: IfcFurnitureType; IfcExportType: USERDEFINED; InstallationDate: 31-12-1900 23:59; Manufacturer: info@dolphinsolutions.co.uk; ManufacturerName: DolphinsolutionsLimited; ManufacturerURL: http://www.dolphinsolutions.co.uk/; Material: Brass Chrome Plated; ModelNumber: BC5083-13; ModelReference: ShowerCurtainHooks_DolphinSolutionsLimited_BC5083-13; Name: ShowerCurtainHooks_BC5083-13_DolphinSolutionsLimited; ObjectClassification1: OmniClass; ObjectClassification2: 23.45.05.14.17; OmniClass Number: 23.40.20.21.44; OmniClass Title: Shower Rods, Curtains; Product Information: https://www.dolphinsolutions.co.uk/product/dolphin-curtain-hooks-brass-chrome-plated/; ReplacementCost: n/a; SustainabilityPerformance: n/a; TagNumber: n/a; Type Name: BC5083-13; WarrantyDescription: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: year; WarrantyGuarantorLabor: DolphinSolutionsLimited; WarrantyGuarantorParts: DolphinSolutionsLimited; WarrantyStartDate: 31-12-1900 23:59
Type - Other - Category: Plumbing Fixtures; Family Name: BC5083-13
Type - Pset_FurnitureTypeCommon - Description: Shower curtain hooks
Pset_ElementShading - Color: Chrome
Pset_ManufacturerOccurrence - BarCode: n/a
Pset_ManufacturerTypeInformation - ModelReference: ShowerCurtainHooks_DolphinSolutionsLimited_BC5083-13; Manufacturer: info@dolphinsolutions.co.uk
Pset_ProductRequirements - Name: ShowerCurtainHooks_BC5083-13_DolphinSolutionsLimited; Category: Plumbing Fixtures
Pset_QuantityTakeOff - Reference: BC5083-13:BC5083-13
Constraints - Level: Level: Level 1; Moves With Nearby Elements: no; Elevation from Level: 2025 mm; Host: Level : Level 1; Offset from Host: 2025 mm
Dimensions - Area: 0.0013773 m2; Volume: 0.00000205534 m3
Other - Family: BC5083-13: BC5083-13; Family and Type: BC5083-13: BC5083-13; Type: BC5083-13: BC5083-13; Type Id: BC5083-13: BC5083-13
Phasing - Phase Created: Phase 1
Name (BC5083-13:BC5083-13:...) | Mark
496117 | 430
496118 | 431
496119 | 432
496120 | 433
496121 | 434
496122 | 435
496123 | 436
496124 | 437
496125 | 438
496126 | 439
496127 | 440
496128 | 441
496130 | 443
496131 | 444
496132 | 445
496133 | 446
496134 | 447
496135 | 448
496136 | 449
496137 | 450
496138 | 451
496139 | 452
496140 | 453
496141 | 454

# IfcFurnishingElement: BC5083-14 (2)
In: Level 1
Type - Constraints - Default Elevation: 0 mm
Type - Identity Data - AccessibilityPerformance: n/a; AssetIdentifier: n/a; AssetType: Fixed; BarCode: n/a; CodePerformance: n/a; Color: White; Constituents: n/a; Description: Shower curtain; DurationUnit: year; ExpectedLife: n/a; Features: n/a; Finish: n/a; Grade: 304; IfcExportAs: IfcFurnitureType; IfcExportType: USERDEFINED; InstallationDate: 31-12-1900 23:59; Manufacturer: info@dolphinsolutions.co.uk; ManufacturerName: DolphinsolutionsLimited; ManufacturerURL: http://www.dolphinsolutions.co.uk/; Material: 4oz Weighted White Polyester; ModelNumber: BC5083-14; ModelReference: ShowerCurtain_DolphinSolutionsLimited_BC5083-14; Name: ShowerCurtain_BC5083-14_DolphinSolutionsLimited; NominalHeight: 1830 mm; NominalLength: 1830 mm; ObjectClassification1: OmniClass; ObjectClassification2: 23.45.05.14.17; OmniClass Number: 23.40.20.21.44; OmniClass Title: Shower Rods, Curtains; Product Information: https://www.dolphinsolutions.co.uk/product/dolphin-shower-curtain/; ReplacementCost: n/a; Size: 1830x1830; SustainabilityPerformance: n/a; TagNumber: n/a; Type Name: BC5083-14; WarrantyDescription: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: year; WarrantyGuarantorLabor: DolphinSolutionsLimited; WarrantyGuarantorParts: DolphinSolutionsLimited; WarrantyStartDate: 31-12-1900 23:59
Type - Other - Category: Plumbing Fixtures; Family Name: BC5083-14
Type - Pset_FurnitureTypeCommon - Description: Shower curtain
Pset_ElementShading - Color: White
Pset_ManufacturerOccurrence - BarCode: n/a
Pset_ManufacturerTypeInformation - ModelReference: ShowerCurtain_DolphinSolutionsLimited_BC5083-14; Manufacturer: info@dolphinsolutions.co.uk
Pset_ProductRequirements - Name: ShowerCurtain_BC5083-14_DolphinSolutionsLimited; Category: Plumbing Fixtures
Pset_QuantityTakeOff - Reference: BC5083-14:BC5083-14
Constraints - Level: Level: Level 1; Moves With Nearby Elements: no; Elevation from Level: 125 mm; Host: Level : Level 1; Offset from Host: 125 mm
Dimensions - Area: 1.91829 m2; Volume: 0.00191533 m3
Other - Family: BC5083-14: BC5083-14; Family and Type: BC5083-14: BC5083-14; Type: BC5083-14: BC5083-14; Type Id: BC5083-14: BC5083-14
Phasing - Phase Created: Phase 1
Name (BC5083-14:BC5083-14:...) | Mark
496116 | 429
496129 | 442

# IfcFurnishingElement: BC5083-33, BC5083-33:BC5083-33:495755
In: Level 1
Type - Constraints - Default Elevation: 0 mm
Type - Identity Data - AccessibilityPerformance: n/a; AssetIdentifier: n/a; AssetType: Fixed; BarCode: n/a; Category: Pr_40_20_06_83:Shower seats; CodePerformance: BSEN12182; Color: Pale grey_white metal; Constituents: n/a; Description: Shower seat; DurationUnit: year; ExpectedLife: n/a; Finish: n/a; IfcExportAs: IfcFurnitureType; IfcExportType: CHAIR; InstallationDate: 31-12-1900 23:59; Manufacturer: info@dolphinsolutions.co.uk; ManufacturerName: DolphinsolutionsLimited; ManufacturerURL: http://www.dolphinsolutions.co.uk/; Material: DiecastAluminium_VacuumMouldedPolyethylene; ModelNumber: BC5083-33; ModelReference: ShowerSeats_DolphinSolutionsLimited_BC5083-33_ShowerSeat; Name: ShowerSeats_BC5083-33_ShowerSeat_DolphinSolutionsLimited; NBSDescription: Shower seats; NBSReference: 45-35-72/352; NominalHeight: 220 mm; NominalLength: 650 mm; NominalWidth: 450 mm; ObjectClassification1: OmniClass; ObjectClassification2: 23.45.05.14.11.17; OmniClass Number: 23.45.05.14.11.17; OmniClass Title: Shower/Bath Seats; Product Information: https://www.dolphinsolutions.co.uk/product/dolphin-shower-seat/; ReplacementCost: n/a; Shape: Rectangular; Size: 450x650x220; SustainabilityPerformance: n/a; TagNumber: n/a; Type Name: BC5083-33; Uniclass2015Code: Pr_40_20_06_83; Uniclass2015Title: Shower seats; WarrantyDescription: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: year; WarrantyGuarantorLabor: DolphinSolutionsLimited; WarrantyGuarantorParts: DolphinSolutionsLimited; WarrantyStartDate: 31-12-1900 23:59
Type - Other - Category: Plumbing Fixtures; Family Name: BC5083-33
Type - Pset_FurnitureTypeCommon - Description: Shower seat
Pset_ElementShading - Color: Pale grey_white metal
Pset_ManufacturerOccurrence - BarCode: n/a
Pset_ManufacturerTypeInformation - ModelReference: ShowerSeats_DolphinSolutionsLimited_BC5083-33_ShowerSeat; Manufacturer: info@dolphinsolutions.co.uk
Pset_ProductRequirements - Name: ShowerSeats_BC5083-33_ShowerSeat_DolphinSolutionsLimited; Category: Plumbing Fixtures
Pset_QuantityTakeOff - Reference: BC5083-33:BC5083-33
Constraints - Level: Level: Level 1; Moves With Nearby Elements: no; Elevation from Level: 485 mm; Host: Level : Level 1; Offset from Host: 485 mm
Dimensions - Area: 0.372725 m2; Volume: 0.0101955 m3
Identity Data - Mark: 103
Other - Family: BC5083-33: BC5083-33; Family and Type: BC5083-33: BC5083-33; Type: BC5083-33: BC5083-33; Type Id: BC5083-33: BC5083-33
Phasing - Phase Created: Phase 1

# IfcFurnishingElement: BC5083-34, BC5083-34:BC5083-34:495754
In: Level 1
Type - Constraints - Default Elevation: 0 mm
Type - Identity Data - AccessibilityPerformance: n/a; AssetIdentifier: n/a; AssetType: Fixed; BarCode: n/a; Category: Pr_40_20_06_83:Shower seats; Color: Pale grey_white metal; Constituents: n/a; Description: Shower seat back rest; DurationUnit: year; ExpectedLife: n/a; Finish: n/a; IfcExportAs: IfcFurnitureType; IfcExportType: USERDEFINED; InstallationDate: 31-12-1900 23:59; Manufacturer: info@dolphinsolutions.co.uk; ManufacturerName: DolphinsolutionsLimited; ManufacturerURL: http://www.dolphinsolutions.co.uk/; Material: DiecastAluminium_VacuumMouldedPolyethylene; ModelNumber: BC5083-34; ModelReference: ShowerSeat_DolphinSolutionsLimited_BC5083-34_ShowerSeatBackRest; Name: ShowerSeat_BC5083-34_ShowerSeatBackRest_DolphinSolutionsLimited; NBSDescription: Shower seats; NBSReference: 45-35-72/352; NominalHeight: 189 mm; NominalLength: 160 mm; NominalWidth: 450 mm; ObjectClassification1: OmniClass; ObjectClassification2: 23.45.05.14.11.17; OmniClass Number: 23.45.05.14.11.17; OmniClass Title: Shower/Bath Seats; Product Information: https://www.dolphinsolutions.co.uk/product/dolphin-shower-back-rest/; ReplacementCost: n/a; Shape: Rectangular; Size: 450x160x189; SustainabilityPerformance: n/a; TagNumber: n/a; Type Name: BC5083-34; Uniclass2015Code: Pr_40_20_06_83; Uniclass2015Title: Shower seats; WarrantyDescription: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: year; WarrantyGuarantorLabor: DolphinSolutionsLimited; WarrantyGuarantorParts: DolphinSolutionsLimited; WarrantyStartDate: 31-12-1900 23:59
Type - Other - Category: Plumbing Fixtures; Family Name: BC5083-34
Type - Pset_FurnitureTypeCommon - Description: Shower seat back rest
Pset_ElementShading - Color: Pale grey_white metal
Pset_ManufacturerOccurrence - BarCode: n/a
Pset_ManufacturerTypeInformation - ModelReference: ShowerSeat_DolphinSolutionsLimited_BC5083-34_ShowerSeatBackRest; Manufacturer: info@dolphinsolutions.co.uk
Pset_ProductRequirements - Name: ShowerSeat_BC5083-34_ShowerSeatBackRest_DolphinSolutionsLimited; Category: Plumbing Fixtures
Pset_QuantityTakeOff - Reference: BC5083-34:BC5083-34
Constraints - Level: Level: Level 1; Moves With Nearby Elements: no; Elevation from Level: 820 mm; Host: Level : Level 1; Offset from Host: 820 mm
Dimensions - Area: 0.152202 m2; Volume: 0.00723579 m3
Identity Data - Mark: 102
Other - Family: BC5083-34: BC5083-34; Family and Type: BC5083-34: BC5083-34; Type: BC5083-34: BC5083-34; Type Id: BC5083-34: BC5083-34
Phasing - Phase Created: Phase 1
